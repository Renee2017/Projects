# Keil uVision project Key.uvprojx, settings and files
target Key (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Key +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Library;..\Library\inc;..\Hardware;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: stm32f10x_it.c main.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group Library
    ../Library/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c
    ../Library/: Delay.c
  group Hardware
    ../Hardware/: Key.c Led.c Led_Exti.c
